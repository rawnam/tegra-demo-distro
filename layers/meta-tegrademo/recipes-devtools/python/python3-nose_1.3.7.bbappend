do_install:append() {
    rm -rf ${D}/usr/man
}